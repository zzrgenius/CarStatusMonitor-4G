# Keil uVision project CarStatusMonitor.uvprojx, settings and files
target CarStatusMonitor (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: CarStatusMonitor
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,MPU9250,EMPL,EMPL_TARGET_STM32F4,MPL_LOG_NDEBUG=1, __CC_ARM,__TARGET_FPU_VFP,ARM_MATH_CM4,USE_CAL_HW_REGISTERS,HWREF_B_CELL_BG96_V2
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Middlewares/Third_Party/FatFs/src;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Drivers/CMSIS/Include;..\App;..\App\mavlink;..\App\libcrc-2.0\include;..\App\SFUD\inc;..\App\easyflash\inc;..\App\calender;..\App\mpu_core\driver\include;..\App\mpu_core\mllite;..\App\mpu_core\eMPL-hal;..\App\mpu_core\driver\eMPL;..\App\mpu_core\mpl;..\App\mpu_core\driver\stm32L;..\App\common;..\App\nmealib\include;..\App\bsp;..\App\mpu_core;..\App\log;..\App\sensors;..\App\sensors\embedded-sht\embedded-common;..\App\sensors\embedded-sht\sht3x;..\App\sensors\embedded-sht\sht-common;..\App\sensors\BMP280_driver;..\App\camera;..\Cellular\Misc\StackAnalysis\inc;..\Cellular\Misc\inc;..\App\sim7600
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c gpio.c adc.c crc.c dcmi.c dma.c bsp_driver_sd.c sd_diskio.c fatfs.c fatfs_platform.c user_diskio.c freertos.c i2c.c rtc.c sdio.c spi.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_TIM.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f4xx.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Task
    ../App/task/: gps_task.c mpu_task.c SD_Task.c gsm_task.c sensors_task.c
  group Bsp
    ../App/bsp/: bsp_dwt.c bsp_led.c bsp_rs485.c bsp_serial.c bsp.c
  group MPU
    ../App/mpu_core/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../App/mpu_core/driver/stm32L/: log_stm32.c
    ../App/mpu_core/eMPL-hal/: eMPL_outputs.c
    ../App/mpu_core/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
    ../App/mpu_core/mpl/: libmpllib.lib
    ../App/mpu_core/: mpu9250_driver.c storage_imudata.c
  group Mavlink
    ../App/: mav_msg.c
  group sfud
    ../App/SFUD/port/: sfud_port.c
    ../App/SFUD/src/: sfud.c sfud_sfdp.c
  group easyflash
    ../App/easyflash/port/: ef_port.c
    ../App/easyflash/src/: ef_env.c easyflash.c ef_utils.c
  group Common
    ../App/calender/: rtc_time.c
    ../App/libcrc-2.0/src/: crc16.c crcccitt.c
    ../App/common/: filter.c utilities.c ringbuffer.c osprintf.c time.c kservice.c
  group GPS
    ../App/nmealib/src/: parser.c info.c context.c parse.c tok.c
  group log
    ../App/log/: aws_logging_task_dynamic_buffers.c
  group Sensors
    ../App/sensors/embedded-sht/sht3x/: sht3x.c sht3x_example_usage.c
    ../App/sensors/embedded-sht/embedded-common/hw_i2c/sample-implementations/STM32F1_series/: sensirion_hw_i2c_implementation.c
    ../App/sensors/embedded-sht/embedded-common/: sensirion_common.c
    ../App/sensors/BMP280_driver/: bmp280.c
    ../App/sensors/BMP280_driver/examples/: pressure.c
    ../App/sensors/: opt3001.c opt3001-2.c os_i2c.c
  group Camera
    ../App/camera/: ov2640_camera.c ov2640.c
  group SIM7600
    ../App/sim7600/: sim_drv.c sim_core.c sim_custom.c sim_service.c sim_service_os.c
  group misc
    ../Cellular/Misc/StackAnalysis/src/: stack_analysis.c
    ../Cellular/Misc/src/: error_handler.c time_date.c trace_interface.c
software components: CMSIS:CORE 4.3.0
